# Repository ECESeniorDesign/greenhouse_envmgmt

File README.rst:

===========
Greenhouse Environment Manager
===========

This package contains models for interacting with the greenhouse sensor and control modules used for an automated tabletop greenhouse.

The README will be expanded as development continues, including detailed API usage.

## KiCad design hardware/kicad/sensor_module_1_0.kicad_pcb

Schematic: sensor_module_1_0.sch

Parts:
1k1: Rb0; R_0805_HandSoldering
C0, C1, C2, C3, C4: .01uF; C_0805_HandSoldering
JP0, JP1, JP2: JUMPER3; Pin_Header_Straight_1x03
P0: CONN_01X05_pwr; Socket_Strip_Straight_1x05
P1: CONN_01X03; Socket_Strip_Straight_1x03
P2: CONN_01X04_ADC; Socket_Strip_Straight_1x04
Q0: PN2222A; TO-92_Horizontal2_Molded_Narrow
Rp0, Rp1, Rp2, Rp3, Rp4, Rp5, Rp6, Rp7, Rp8, Rp9, Rp10, Rp11: 2.4k; R_0805_HandSoldering
U0: TCA9546a; SO-16-N
U1: STLM75M2F; SOIC-8
U2: TSL2550D; SOIC-8
U3: MCP3422A0-E/SN; SOIC-8
U4: HIH7121; SIP4_50mil

Connections:
/GND: C0.1, C1.2, C2.1, C3.1, C4.2, JP0.3, JP1.3, JP2.3, P0.1, Q0.1, U0.8, U1.4 (GND), U1.6 (A0), U1.7 (A1), U1.8 (A2), U2.4 (GND), U3.2 (CH1-), U3.6 (VSS), U4.2 (VSS)
/GND_sensor: P1.3, P2.4, Q0.3
/GPIO_TOG: 1k1.2, P0.5
/VDD: C0.2, C1.1, C2.2, C3.2, C4.1, JP0.1, JP1.1, JP2.1, P0.2, P1.1, P2.1, Rp0.2, Rp1.2, Rp2.2, Rp3.2, Rp4.2, Rp5.2, Rp6.2, Rp7.2, Rp8.1, Rp9.1, Rp10.2, Rp11.1, U0.16, U1.5 (VDD), U2.1 (VDD), U3.3 (VDD), U4.1 (VDD)
unnamed: 1k1.1, Q0.2
unnamed: JP0.2, U0.1
unnamed: JP1.2, U0.2
unnamed: JP2.2, U0.13
unnamed: P0.3, Rp3.1, U0.15
unnamed: P0.4, Rp4.1, U0.14
unnamed: P1.2, U3.1 (CH1+)
unnamed: P2.2, U3.8 (CH2-)
unnamed: P2.3, U3.7 (CH2+)
unnamed: Rp0.1, U0.11, U1.1 (SDA)
unnamed: Rp1.1, U1.3 (~OS~/INT)
unnamed: Rp2.1, U0.12, U1.2 (SCL)
unnamed: Rp5.1, U0.3
unnamed: Rp6.1, U0.4, U2.5 (SMBData)
unnamed: Rp7.1, U0.5, U2.8 (SMBCLK)
unnamed: Rp8.2, U0.10, U3.5 (SCL)
unnamed: Rp9.2, U0.9, U3.4 (SDA)
unnamed: Rp10.1, U0.6, U4.4 (SDA)
unnamed: Rp11.2, U0.7, U4.3 (SCL)

Board: 2 copper layers, 91.4 x 58.4 mm, 30 parts (0 on the bottom side), 23 nets.

## KiCad design hardware/kicad/sensor_module.kicad_pcb

Parts:
C1, C4, C5, C6, C7: 100nF; C_0201
JPA0, JPA1, JPA2: JUMPER; Pin_Header_Straight_1x02
JPB0, JPB1: Jumper_NC_Small; Pin_Header_Straight_1x02
P1: CONN_01X04; Socket_Strip_Angled_1x04
P2: PH_Sensor; Socket_Strip_Angled_1x02
P3: Moisture_Sensor; Socket_Strip_Angled_1x03
R1, R2: 3.6k; R_0201
R7, R8, R9, R10, R11: 330k; R_0201
R12, R13: 3600; R_0201
R16, R17, R19: 2500; R_0201
R18: 10k; R_0201
U0: STLM75M2F; SOIC-8-N
U1: TCA9543ADR; SOIC-14_N
U2: TSL2550D; SOIC-8-N
U3: HIH7121; SIP4
U4: MCP3422A0-E/SN; SOIC-8-N

Connections:
/GND: C1.2, C4.1, C5.2, C6.2, C7.2, P1.3, P3.3, R7.2, R8.2, R9.2, R10.1, R11.1, U0.4 (GND), U1.4, U1.7, U1.8, U1.11, U2.4 (GND), U3.2 (VSS), U4.6 (VSS), U4.8 (CH2-)
/SCL: P1.1, R2.1, U0.2 (SCL), U1.12, U4.5 (SCL)
/SDA: P1.2, R1.2, U0.1 (SDA), U1.13, U4.4 (SDA)
/VDD: C1.1, C4.2, C5.1, C6.1, C7.1, JPA0.1, JPA1.1, JPA2.1, JPB0.2, JPB1.2, P1.4, P3.1, R1.1, R2.2, R12.1, R13.1, R16.1, R17.1, R18.2, R19.1, U0.5 (VDD), U1.14, U2.1 (VDD), U3.1 (VDD), U4.3 (VDD)
unnamed: JPA0.2, R7.1, U0.6 (A0)
unnamed: JPA1.2, R8.1, U0.7 (A1)
unnamed: JPA2.2, R9.1, U0.8 (A2)
unnamed: JPB0.1, R11.2, U1.1
unnamed: JPB1.1, R10.2, U1.2
unnamed: P2.1, U4.2 (CH1-)
unnamed: P2.2, U4.1 (CH1+)
unnamed: P3.2, U4.7 (CH2+)
unnamed: R12.2, U1.6, U2.8 (SMBCLK)
unnamed: R13.2, U1.5, U2.5 (SMBData)
unnamed: R16.2, U1.9, U3.4 (SDA)
unnamed: R17.2, U1.10, U3.3 (SCL)
unnamed: R18.1, U1.3
unnamed: R19.2, U0.3 (~OS~/INT)

Notes on the sheet:
Use 22 or 24 gauge wire at 4-pin connector

Board: 2 copper layers, 85.1 x 55.9 mm, 31 parts (0 on the bottom side), 18 nets.

## Commit log (part)

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2015-12-13 Functioning demo script to read temperature and lux
    Script prints out current temperature and accesses the light sensors two
    photodiodes to collect data, calculating the LUX based on this data.
    See issue #2
2016-01-15 #6: Initial sensor cluster models added
    Initial model layout for a sensor cluster that should be easier to
    manage and expand on than the previous script `i2c_read_nodes.py`
2016-01-15 #6: Added method to save values
    Also added some base functionality to test how exception handling could
    work during the sensor update stage. This should be ready to go into an
    implementation at this point.
2016-01-17 #3, #6: Verified I2C Bus Multiplexor. Verified sensor cluster base functions
    As per issue 3, the I2C multiplexer appears to be responding to
    switching commands and successfully routing I2C commands through to the
    correct module.
    As per issue 6, the sensor cluster class and its respective methods
    appear to be working as intended. Creating individual SensorCluster
    modules with all of the needed information to carry out data acquisition
2016-01-20 #2 Added support for humidity sensors
    Added functionality supporting the I2C humidity sensor modules in
    preparation for when they arrive later this week.
2016-01-21 Fixed formatting and saveAllSensors function
2016-01-24 #8 Initial prototype of PCB Added
    The files added as part of this commit are all associated with the first
    prototype of the PCB. I'll be removing a lot of these files later on as
    I figure out exactly what files are needed in order for someone else to
    view and generate the files needed to print their own board.
    A 3D rendering of the board has also been added.
2016-01-24 #8 Fixed Rendered Image
2016-01-26 Close #2: Implemented Humidity Sensor Module
    The humidity sensor is working properly and currently measuring ambient
    humidity.
    It has a feature that will measure temperature as well. I intend to use
    this feature to verify that the device is working properly and if it's
    accurate enough, I may remove the dedicated temperature sensor.
2016-01-26 #11
    Added initial controls interface. This is likely going to change a lot,
    but serves as a good basis for brainstorming.
2016-01-26 Revert "#11"
    This reverts commit 28d478cf875b84b6ed53a8ed2858f7f37014f470.
2016-01-28 Restructured Sensor Model
    This new sensor model structure hides each sensor cluster behind a
    single node head (in this case, the node head is an I2C multiplexer).
    This eliminates the need for individual sensor addresses and further
    generalizes the models. This also abstracts more hardware away from the
    python script and thus will make it easier for a user to add sensors.
2016-01-30 #11: Created control model, added support for IO expander
    The control model contained in this commit should make interfacing to
    the control modules a little bit easier by abstracting a lot of low
    level register manipulation into the model.
    Each control cluster will need to be instantiated with an ID. It will
    also receive a SensorCluster object (of the same ID) and a list of ideal
    values for the given plant.
2016-01-31 #11 Tested Control Models
    controltest.py contains a short script that creates a couple of control
    objects and runs through the methods and accesses various fields that
    would be used in control-type situations
2016-02-03 Close #5: Added soil moisture sensing
    Soil moisture sensors now have full support. I'm closing this issue as
    we may be removing pH sensing from the project for now, though space
    will exist on the ADC to measure an additional parameter.
    As of this update, the plant sensor prototype is functionally complete.
    Calibration may be needed to dial in the soil moisture sensor when it's
    used in soil, but this will be a simple mapping function if it is even
2016-02-04 update interface to webservice
2016-02-06 #8 Revised PCB to reflect new sensor module structure
    The PCB design files included with this commit are tentatively ready for
    a design review.
    In order to view the files on another computer, the .mod and .lib files
    are needed. I will attempt to package these in a more convenient way at
    a later point.
2016-02-07 #8 Added gerbers and rendering of revised PCB
    The PCB has been shrunk down by about 4 square inches and labelling to
    make it more user friendly has been added where appropriate.
    I will also be removing any kicad files in favor of keeping only gerbers
    and renderings available.
2016-02-07 #8 Added rendering
    As per last commit, I've moved the rendering out of the kicad folder.
2016-02-10 #13 Reworked Sensor Module API
    The sensor module now exposes a fairly simple set of methods that allow
    the user to update all sensors for all modules with one function call,
    update individual sensors for a single plant, or update all sensors for
    a single plant.
    Saving can be done either on a batch update or on request.
2016-02-10 #13 Reworked Sensor API
    The sensor module now exposes a fairly simple set of methods that allow
    the user to update all sensors for all modules with one function call,
    update individual sensors for a single plant, or update all sensors for
    a single plant.
    Saving can be done either on a batch update or on request.
    This is a re-do of a previous commit.
2016-02-11 Added support for robustness testing and data logging
    Modifications to the sensortest script as well as the sensor models now
    support extended robustness testing and data logging.
    To illustrate, I have attached a log that ran 200 consecutive sensor
    update and save commands.
2016-02-11 Added support for robustness testing and data logging
    Reference commit 9f34c8dc067e84ed4f21012804cf462e6066639a
    I somehow forgot to include the correct files in the original commit.
    This adds support for robustness tests and data logging and includes one
    200 point sample test.
2016-02-14 #8 Uploaded production version of module
    The gerber files in this commit as well as the 3d render match what was
    uploaded to Osh Park.
2016-02-20 Close #15: Fixed Light Sensor Errors and Readout
    Fixed an issue where the TSL2550D light sensor occasionally refused to
    respond to commands intermittently. This specific issue was tied to the
    lack of a forced wait time for onboard ADC conversion. The downside of
    this fix is that - in order to correctly acquire results - it takes
    nearly a second to convert ADC results. A possible solution to this
    method would be to use the extended mode, which reduces total wait time
2016-02-21 #13 Added extended lux operation.
    User can now select extended (which is faster) or standard (which has
    800ms delay) modes of operation on the TSL2550D lux sensor.
    Sensor code and the API has been cleaned up slightly.
2016-02-21 #13 Improved pump support and API
    This commit has two main features:
    1) The pump is now governed by a list that each control object is
    capable of accessing through the parent class. If any of the components
    of this list are int(1), the pump will turn on. I may later add support
    for different options here, but this would be easiest to interface with
    valves if we intend to keep support for them.
2016-02-21 cleaned up ControlCluster.control method
2016-02-21 live mask generation
2016-02-21 Created master mask so that the controls class has knowledge of each object's requests. Controls objects now make pump requests and these requests are compiled to the master mask later on. The change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
    The method to update the tank water level has also been removed from the control model and will be readded as part of the sensor model later on.
2016-02-21 Revert "Committing latest changes to prepare for merge"
    This reverts commit e1b8efc0e4fc211f80d6a803b62acd5556291187.
2016-02-21 Fixed bug causing pump to lock in on state
    The existence of pump_operation was causing a self-locking loop, so that
    once the pump_operation bit was set high, it was difficult to get the
    pump to turn off. This has been completely removed from the control
    model.
2016-02-22 abstract away bus
2016-02-23 Migrated analog sensor power control to SensorCluster class
    Changes have been tested and varified. A method was added to the I2C utilities to allow a module to read the contents of the IO modules two IO banks. This prevents any conflicts where the SensorClust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
2016-02-23 Fixed horrible errors with last commit.
    Strangely enough, none of the diff tags showed up on my windows host. Odd.
2016-02-25 Added CAD files for greenhouse structure
    These files serve as a preliminary sketch as to the dimensions and features of the greenhouse. The light fixtures have no means of mounting in these files, as a support beam can be added at a later p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
2016-02-25 Fixed ADC Value Retrieval
    Corrected error in ratiometric scaling where the result was off by a factor of two. The problem was due to failing to recognize that since it's a differential ADC, one bit of the resolution is used t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
2016-02-27 Added download URL
2016-02-27 Fixed setup.py
    Forgot to commit the setup file after creating PyPi last night.
2016-02-28 Removed Greenhouse Sketches
    These sketches are no longer needed. New ones may be added at a later
    date once the design is finalized.
2016-03-21 corrected imports
2016-03-22 #19 Edited sensor tests to work with new interface
2016-03-29 Close #9. Fixed ADC and verified that sensor is working.
    The sensor appears to be working and the pi is able to get the water
    level within about a quarter of a centimeter.
    We will need to add the water level sensor to a tube of some sort in
    order to keep it rigid and exposed to water.
    The ADC changes should also be reflected in the soil moisture sensor.
    This change can be made during calibration.
2016-04-11 Changed IO Map; Altered import_addr utilities
2016-04-11 Fixed issue with previous commit
    A couple of necessary changes was left out of the last commit by
    mistake.
    The analog power pin has been moved (as it was previously tied to the
    control for the pump) and the method `import_i2c_addr()` has been
    changed to return sensor addresses by default.
2016-04-12 #25 Re-calibrated depth sensor and scaled soil moisture sensor
    Offset for depth sensor was too large and has been decreased to more
    accurately reflect the values. It appears that the small measurements
    threw off the calculated slope (or the slight nonlinearity meant that it
    went off target. Additionally, the size of the container was too large
    in the file and has been lowered.
    The soil moisture now represents itself as a value from 0 (being dry
2016-04-12 #25: Recalibrated sensors (see 58bc92b)
    This commit includes a file that was supposed to be part of the 58bc92b
    commit.
2016-04-14 Fixed sensor automatic addressing
    Extraneous imports have also been removed from the sensortest script.
2016-04-18 #25 Corrected soil moisture scaling
2016-04-18 Models should stop being there now.
2016-04-19 Added light ratio to help determine ambient light quality
    light_ratio will be used to satisfy issue 26 in the
    greenhouse-webservice. Its purpose is to provide data by which a user
    can be notified if the light quality in the room is inadequate
    throughout an entire day (implying that the grow lights would need to be
    on at all times)
2016-04-22 Added controls schematics
2016-04-23 #26 Initial refactoring commit
    Environment sensors and the TCA I2C mux have been moved to individual
    classes in order to make the code more flexible and easier to read.
    This code is untested and will likely not work in its current form.
